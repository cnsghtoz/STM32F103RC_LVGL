<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\f103RC_ST7735_128_160LCD.ewp</path>
  </project>
  <batchBuild />
</workspace>
